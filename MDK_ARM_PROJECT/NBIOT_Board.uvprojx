# Keil uVision project NBIOT_Board.uvprojx, settings and files
target NBIOT_Board (ARM-ADS)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NBIOT_Board
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ..\drivers;..\lib\CMSIS\Include;..\lib\STM32L1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group lib/STM32L1xx_HAL_Driver
    ../lib/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c system_stm32l1xx.c
  group startup
    ../lib/CMSIS/Device/ST/STM32L1xx/: startup_stm32l151xba.s
  group main
    ../main/: main.c
  group drivers
    ../drivers/: delay.c system_clock.c led.c usart.c
